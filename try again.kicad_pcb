# Repository NatDizzy/Miss-Octopus-PCB

File README.md:

# Miss-Octopus-PCB!
Decided to turn an inside joke of mine (Miss Octopus) into a simple PCB board with LED eyes!

##Schematic

##PCB

##3D viewer

##BOM
- 1 Battery Holder
- 1 Push Button Switch
- 2 5.0 mm LEDs
- 2 220 ohm resistors

slack: @Dizzy

## KiCad design try again.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3034_1x20mm
D1, D2: LED; LED_D5.0mm
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_Push; SW_PUSH_6mm

Connections:
unnamed: BT1.1 (+), SW1.1
unnamed: BT1.2 (-), R1.2, R2.2
unnamed: D1.2 (A), D2.2 (A), SW1.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1

Board: 2 copper layers, 100.9 x 87.1 mm, 6 parts (3 on the bottom side), 5 nets.
